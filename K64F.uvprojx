# Keil uVision project K64F.uvprojx, settings and files
target K64F (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: MK64FN1M0xxx12 Freescale
  pack: Keil.Kinetis_K60_DFP.1.4.0
  output: K64F
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c misc: -DTARGET_KSDK2_MCUS -DDEVICE_RTC=1 -DDEVICE_SLEEP=1 -DTOOLCHAIN_object -DTOOLCHAIN_ARM_STD -DTARGET_KPSDK_CODE --split_sections -DFEATURE_LWIP=1 -D__ASSERT_MSG -DTARGET_MCU_K64F --no_rtti -DDEVICE_PORTINOUT=1 -DFEATURE_LOWPAN_ROUTER=1 --multibyte_chars -g -DTARGET_FF_ARDUINO -c -DTARGET_RTOS_M4_M7 -DDEVICE_SPISLAVE=1 -DDEVICE_PORTOUT=1 -DDEVICE_STDIO_MESSAGES=1 -DDEVICE_ANALOGOUT=1 -DTARGET_LIKE_MBED -DDEVICE_SERIAL_FC=1 --brief_diagnostics -DTARGET_FRDM -DFEATURE_STORAGE=1 -DTARGET_LIKE_CORTEX_M4 -DARM_MATH_CM4 -DDEVICE_ERROR_RED=1 -DTARGET_CORTEX_M -DDEVICE_SERIAL=1 -DTARGET_KPSDK_MCUS -DTARGET_Freescale --restrict -DDEVICE_I2C=1 --preinclude=mbed_config.h -D__CORTEX_M4 --cpu=Cortex-M4.fp -DDEVICE_TRNG=1 -DDEVICE_LOWPOWERTIMER=1 -DTARGET_MCUXpresso_MCUS -DTOOLCHAIN_ARM -DDEVICE_INTERRUPTIN=1 -DDEVICE_ANALOGIN=1 --no_depend_system_headers -DTARGET_UVISOR_UNSUPPORTED -D__CMSIS_RTOS --md -DDEVICE_PWMOUT=1 -DDEVICE_SERIAL_ASYNCH=1 -DMBED_BUILD_TIMESTAMP=1487502681.85 --gnu -DTARGET_DEBUG -DFEATURE_COMMON_PAL=1 --apcs=interwork -DDEVICE_SPI=1 -D__MBED__=1 -DTARGET_K64F -DCPU_MK64FN1M0VMD12 -DDEVICE_STORAGE=1 -DDEVICE_PORTIN=1 -DTARGET_M4 -D__FPU_PRESENT=1 -DDEVICE_I2CSLAVE=1 -DFSL_RTOS_MBED -DDEVICE_SPI_ASYNCH=1 -D__MBED_CMSIS_RTOS_CM -DFEATURE_NANOSTACK=1
  c include: .; ./easy-connect; ./easy-connect/atmel-rf-driver; ./easy-connect/atmel-rf-driver/atmel-rf-driver; ./easy-connect/atmel-rf-driver/source; ./easy-connect/esp8266-driver; ./easy-connect/esp8266-driver/ESP8266; ./easy-connect/esp8266-driver/ESP8266/ATParser; ./easy-connect/esp8266-driver/ESP8266/ATParser/BufferedSerial; ./easy-connect/esp8266-driver/ESP8266/ATParser/BufferedSerial/Buffer; ./easy-connect/mcr20a-rf-driver; ./easy-connect/mcr20a-rf-driver/mcr20a-rf-driver; ./easy-connect/mcr20a-rf-driver/source; ./JSON; ./mbed-http; ./mbed-http/http_parser; ./mbed-http/source; ./mbed-os; ./mbed-os/cmsis; ./mbed-os/docs; ./mbed-os/drivers; ./mbed-os/events; ./mbed-os/events/equeue; ./mbed-os/features; ./mbed-os/features/frameworks; ./mbed-os/features/frameworks/greentea-client; ./mbed-os/features/frameworks/greentea-client/greentea-client; ./mbed-os/features/frameworks/greentea-client/source; ./mbed-os/features/frameworks/unity; ./mbed-os/features/frameworks/unity/source; ./mbed-os/features/frameworks/unity/unity; ./mbed-os/features/frameworks/utest; ./mbed-os/features/frameworks/utest/source; ./mbed-os/features/frameworks/utest/utest; ./mbed-os/features/mbedtls; ./mbed-os/features/mbedtls/importer; ./mbed-os/features/mbedtls/inc; ./mbed-os/features/mbedtls/inc/mbedtls; ./mbed-os/features/mbedtls/platform; ./mbed-os/features/mbedtls/platform/inc; ./mbed-os/features/mbedtls/platform/src; ./mbed-os/features/mbedtls/src; ./mbed-os/features/nanostack; ./mbed-os/features/netsocket; ./mbed-os/features/storage; ./mbed-os/hal; ./mbed-os/hal/storage_abstraction; ./mbed-os/platform; ./mbed-os/rtos; ./mbed-os/rtos/rtx; ./mbed-os/rtos/rtx/TARGET_CORTEX_M; ./mbed-os/rtos/rtx/TARGET_CORTEX_M/TARGET_RTOS_M4_M7; ./mbed-os/rtos/rtx/TARGET_CORTEX_M/TARGET_RTOS_M4_M7/TOOLCHAIN_ARM; ./mbed-os/targets; ./mbed-os/targets/TARGET_Freescale; ./mbed-os/targets/TARGET_Freescale/TARGET_MCUXpresso_MCUS; ./mbed-os/targets/TARGET_Freescale/TARGET_MCUXpresso_MCUS/api; ./mbed-os/targets/TARGET_Freescale/TARGET_MCUXpresso_MCUS/TARGET_MCU_K64F; ./mbed-os/targets/TARGET_Freescale/TARGET_MCUXpresso_MCUS/TARGET_MCU_K64F/device; ./mbed-os/targets/TARGET_Freescale/TARGET_MCUXpresso_MCUS/TARGET_MCU_K64F/device/TOOLCHAIN_ARM_STD; ./mbed-os/targets/TARGET_Freescale/TARGET_MCUXpresso_MCUS/TARGET_MCU_K64F/drivers; ./mbed-os/targets/TARGET_Freescale/TARGET_MCUXpresso_MCUS/TARGET_MCU_K64F/TARGET_FRDM; ./MQTT; ./MQTT/FP; ./MQTT/MQTTPacket; ./MQTT/MQTTPacket/samples; ./MQTT/MQTTPacket/test; ./NTPClient; ./SDFileSystem; ./SDFileSystem/FATFileSystem; ./SDFileSystem/FATFileSystem/ChaN; ./SPI_STMPE610; ./SPI_TFT_ILI9341; ./TFT_fonts; ./XBeeLib; ./XBeeLib/DigiLogger; ./XBeeLib/FrameBuffer; ./XBeeLib/FrameHandlers; ./XBeeLib/Frames; ./XBeeLib/IO; ./XBeeLib/RemoteXBee; ./XBeeLib/Utils; ./XBeeLib/XBee; ./XBeeLib/XBee802; ./XBeeLib/XBeeDM; ./XBeeLib/XBeeZB; ./mbed-os/features/FEATURE_LWIP; ./mbed-os/features/FEATURE_LWIP/lwip-interface; ./mbed-os/features/FEATURE_LWIP/lwip-interface/lwip; ./mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src; ./mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/api; ./mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/core; ./mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/core/ipv4; ./mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/core/ipv6; ./mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/include; ./mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/include/lwip; ./mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/include/lwip/priv; ./mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/include/netif; ./mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/include/netif/ppp; ./mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/include/netif/ppp/polarssl; ./mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/netif; ./mbed-os/features/FEATURE_LWIP/lwip-interface/lwip-eth; ./mbed-os/features/FEATURE_LWIP/lwip-interface/lwip-eth/arch; ./mbed-os/features/FEATURE_LWIP/lwip-interface/lwip-eth/arch/TARGET_Freescale; ./mbed-os/features/FEATURE_LWIP/lwip-interface/lwip-sys; ./mbed-os/features/FEATURE_LWIP/lwip-interface/lwip-sys/arch; ./mbed-os/features/nanostack/FEATURE_NANOSTACK; ./mbed-os/features/nanostack/FEATURE_NANOSTACK/coap-service; ./mbed-os/features/nanostack/FEATURE_NANOSTACK/coap-service/coap-service; ./mbed-os/features/nanostack/FEATURE_NANOSTACK/coap-service/source; ./mbed-os/features/nanostack/FEATURE_NANOSTACK/coap-service/source/include; ./mbed-os/features/nanostack/FEATURE_NANOSTACK/mbed-mesh-api; ./mbed-os/features/nanostack/FEATURE_NANOSTACK/mbed-mesh-api/mbed-mesh-api; ./mbed-os/features/nanostack/FEATURE_NANOSTACK/mbed-mesh-api/source; ./mbed-os/features/nanostack/FEATURE_NANOSTACK/mbed-mesh-api/source/include; ./mbed-os/features/nanostack/FEATURE_NANOSTACK/nanostack-interface; ./mbed-os/features/nanostack/FEATURE_NANOSTACK/sal-stack-nanostack; ./mbed-os/features/nanostack/FEATURE_NANOSTACK/sal-stack-nanostack/docs; ./mbed-os/features/nanostack/FEATURE_NANOSTACK/sal-stack-nanostack/docs/img; ./mbed-os/features/nanostack/FEATURE_NANOSTACK/sal-stack-nanostack/doxygen; ./mbed-os/features/nanostack/FEATURE_NANOSTACK/sal-stack-nanostack/nanostack; ./mbed-os/features/nanostack/FEATURE_NANOSTACK/sal-stack-nanostack/nanostack/platform; ./mbed-os/features/nanostack/FEATURE_NANOSTACK/targets; ./mbed-os/features/storage/FEATURE_STORAGE; ./mbed-os/features/storage/FEATURE_STORAGE/cfstore; ./mbed-os/features/storage/FEATURE_STORAGE/cfstore/configuration-store; ./mbed-os/features/storage/FEATURE_STORAGE/cfstore/doc; ./mbed-os/features/storage/FEATURE_STORAGE/cfstore/doc/design; ./mbed-os/features/storage/FEATURE_STORAGE/cfstore/doc/design/pics; ./mbed-os/features/storage/FEATURE_STORAGE/cfstore/doc/design/umlet; ./mbed-os/features/storage/FEATURE_STORAGE/cfstore/doc/project; ./mbed-os/features/storage/FEATURE_STORAGE/cfstore/source; ./mbed-os/features/storage/FEATURE_STORAGE/flash-journal; ./mbed-os/features/storage/FEATURE_STORAGE/flash-journal/flash-journal-strategy-sequential; ./mbed-os/features/storage/FEATURE_STORAGE/storage-volume-manager; ./mbed-os/features/storage/FEATURE_STORAGE/storage-volume-manager/source; ./mbed-os/features/storage/FEATURE_STORAGE/storage-volume-manager/storage-volume-manager; ./mbed-os/features/nanostack/FEATURE_LOWPAN_ROUTER; ./mbed-os/features/nanostack/FEATURE_LOWPAN_ROUTER/TOOLCHAIN_ARM; ./mbed-os/features/nanostack/FEATURE_LOWPAN_ROUTER/TOOLCHAIN_ARM/TARGET_RTOS_M4_M7; ./mbed-os/features/FEATURE_COMMON_PAL; ./mbed-os/features/FEATURE_COMMON_PAL/mbed-client-c; ./mbed-os/features/FEATURE_COMMON_PAL/mbed-client-c/doxygen; ./mbed-os/features/FEATURE_COMMON_PAL/mbed-client-c/nsdl-c; ./mbed-os/features/FEATURE_COMMON_PAL/mbed-client-c/source; ./mbed-os/features/FEATURE_COMMON_PAL/mbed-client-c/source/libCoap; ./mbed-os/features/FEATURE_COMMON_PAL/mbed-client-c/source/libCoap/src; ./mbed-os/features/FEATURE_COMMON_PAL/mbed-client-c/source/libCoap/src/include; ./mbed-os/features/FEATURE_COMMON_PAL/mbed-client-c/source/libNsdl; ./mbed-os/features/FEATURE_COMMON_PAL/mbed-client-c/source/libNsdl/src; ./mbed-os/features/FEATURE_COMMON_PAL/mbed-client-c/source/libNsdl/src/include; ./mbed-os/features/FEATURE_COMMON_PAL/mbed-client-randlib; ./mbed-os/features/FEATURE_COMMON_PAL/mbed-client-randlib/mbed-client-randlib; ./mbed-os/features/FEATURE_COMMON_PAL/mbed-client-randlib/mbed-client-randlib/platform; ./mbed-os/features/FEATURE_COMMON_PAL/mbed-client-randlib/source; ./mbed-os/features/FEATURE_COMMON_PAL/mbed-trace; ./mbed-os/features/FEATURE_COMMON_PAL/mbed-trace/mbed-trace; ./mbed-os/features/FEATURE_COMMON_PAL/mbed-trace/source; ./mbed-os/features/FEATURE_COMMON_PAL/nanostack-hal-mbed-cmsis-rtos; ./mbed-os/features/FEATURE_COMMON_PAL/nanostack-hal-mbed-cmsis-rtos/cs_nvm; ./mbed-os/features/FEATURE_COMMON_PAL/nanostack-hal-mbed-cmsis-rtos/nvm; ./mbed-os/features/FEATURE_COMMON_PAL/nanostack-libservice; ./mbed-os/features/FEATURE_COMMON_PAL/nanostack-libservice/mbed-client-libservice; ./mbed-os/features/FEATURE_COMMON_PAL/nanostack-libservice/mbed-client-libservice/platform; ./mbed-os/features/FEATURE_COMMON_PAL/nanostack-libservice/source; ./mbed-os/features/FEATURE_COMMON_PAL/nanostack-libservice/source/IPv6_fcf_lib; ./mbed-os/features/FEATURE_COMMON_PAL/nanostack-libservice/source/libBits; ./mbed-os/features/FEATURE_COMMON_PAL/nanostack-libservice/source/libip6string; ./mbed-os/features/FEATURE_COMMON_PAL/nanostack-libservice/source/libList; ./mbed-os/features/FEATURE_COMMON_PAL/nanostack-libservice/source/libTrace; ./mbed-os/features/FEATURE_COMMON_PAL/nanostack-libservice/source/libTrace/scripts; ./mbed-os/features/FEATURE_COMMON_PAL/nanostack-libservice/source/nsdynmemLIB; ./mbed-os/features/FEATURE_COMMON_PAL/nanostack-libservice/source/nvmHelper; ./mbed-os/features/FEATURE_COMMON_PAL/sal-stack-nanostack-eventloop; ./mbed-os/features/FEATURE_COMMON_PAL/sal-stack-nanostack-eventloop/nanostack-event-loop; ./mbed-os/features/FEATURE_COMMON_PAL/sal-stack-nanostack-eventloop/nanostack-event-loop/platform; ./mbed-os/features/FEATURE_COMMON_PAL/sal-stack-nanostack-eventloop/source
  asm misc: --cpreproc --cpreproc_opts=-D__ASSERT_MSG,-D__CORTEX_M4,-DCPU_MK64FN1M0VMD12,-DARM_MATH_CM4,-D__FPU_PRESENT=1,-D__MBED_CMSIS_RTOS_CM,-D__CMSIS_RTOS,-DFSL_RTOS_MBED
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  memory RVCT10: RAM 0x1fffe000 size 0x2000
  scatter file: ./mbed-os/targets/TARGET_Freescale/TARGET_MCUXpresso_MCUS/TARGET_MCU_K64F/device/TOOLCHAIN_ARM_STD/MK64FN1M0xxx12.sct
  group easy-connect
    ./easy-connect/atmel-rf-driver/source/: at24mac.cpp at24mac.h AT86RFReg.h NanostackRfPhyAtmel.cpp
    ./easy-connect/esp8266-driver/ESP8266/ATParser/: ATParser.cpp ATParser.h
    ./easy-connect/esp8266-driver/ESP8266/ATParser/BufferedSerial/: BufferedPrint.c BufferedSerial.cpp BufferedSerial.h
    ./easy-connect/: easy-connect.h
    ./easy-connect/esp8266-driver/ESP8266/: ESP8266.cpp ESP8266.h
    ./easy-connect/esp8266-driver/: ESP8266Interface.cpp ESP8266Interface.h
    ./easy-connect/mcr20a-rf-driver/source/: MCR20Drv.c MCR20Drv.h MCR20Overwrites.h MCR20Reg.h NanostackRfPhyMcr20a.cpp XcvrSpi.h
    ./easy-connect/esp8266-driver/ESP8266/ATParser/BufferedSerial/Buffer/: MyBuffer.cpp MyBuffer.h
    ./easy-connect/atmel-rf-driver/atmel-rf-driver/: NanostackRfPhyAtmel.h
    ./easy-connect/mcr20a-rf-driver/mcr20a-rf-driver/: NanostackRfPhyMcr20a.h
  group JSON
    ./JSON/: jsmn.c jsmn.h Json.cpp Json.h
  group K64F
    ./: config.h GardenConfig.cpp GardenConfig.h main.cpp mbed_config.h mbedtls_entropy_config.h MQTTNetwork.h
  group mbed-http
    ./mbed-http/source/: http_parsed_url.h http_request.h http_request_builder.h http_response.h http_response_parser.h https_request.h
    ./mbed-http/http_parser/: http_parser.c http_parser.h
  group mbed-os
    ./mbed-os/features/mbedtls/src/: aes.c aesni.c arc4.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c net_sockets.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs11.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c ripemd160.c rsa.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
    ./mbed-os/features/mbedtls/inc/mbedtls/: aes.h aesni.h arc4.h asn1.h asn1write.h base64.h bignum.h blowfish.h bn_mul.h camellia.h ccm.h certs.h check_config.h cipher.h cipher_internal.h cmac.h compat-1.3.h config-no-entropy.h config.h ctr_drbg.h debug.h des.h dhm.h ecdh.h ecdsa.h ecjpake.h ecp.h entropy.h entropy_poll.h error.h gcm.h havege.h hmac_drbg.h md.h md2.h md4.h md5.h md_internal.h memory_buffer_alloc.h net.h net_sockets.h oid.h padlock.h pem.h pk.h pk_internal.h pkcs11.h pkcs12.h pkcs5.h platform.h platform_time.h ripemd160.h rsa.h sha1.h sha256.h sha512.h ssl.h ssl_cache.h ssl_ciphersuites.h ssl_cookie.h ssl_internal.h ssl_ticket.h threading.h timing.h version.h x509.h x509_crl.h x509_crt.h x509_csr.h xtea.h
    ./mbed-os/drivers/: AnalogIn.cpp AnalogIn.h AnalogOut.h BusIn.cpp BusIn.h BusInOut.cpp BusInOut.h BusOut.cpp BusOut.h CAN.cpp CAN.h DigitalIn.h DigitalInOut.h DigitalOut.h DirHandle.h Ethernet.cpp Ethernet.h FileBase.cpp FileBase.h FileHandle.h FileLike.cpp FileLike.h FilePath.cpp FilePath.h FileSystemLike.cpp FileSystemLike.h I2C.cpp I2C.h I2CSlave.cpp I2CSlave.h InterruptIn.cpp InterruptIn.h InterruptManager.cpp InterruptManager.h LocalFileSystem.cpp LocalFileSystem.h LowPowerTicker.h LowPowerTimeout.h LowPowerTimer.h PortIn.h PortInOut.h PortOut.h PwmOut.h RawSerial.cpp RawSerial.h Serial.cpp Serial.h SerialBase.cpp SerialBase.h SPI.cpp SPI.h SPISlave.cpp SPISlave.h Stream.cpp Stream.h Ticker.cpp Ticker.h Timeout.cpp Timeout.h Timer.cpp Timer.h TimerEvent.cpp TimerEvent.h
    ./mbed-os/targets/TARGET_Freescale/TARGET_MCUXpresso_MCUS/api/: analogin_api.c analogout_api.c dma_api.c dma_api_hal.h gpio_api.c gpio_irq_api.c gpio_object.h i2c_api.c lp_ticker.c objects.h PeripheralPins.h pinmap.c port_api.c PortNames.h rtc_api.c sleep.c
    ./mbed-os/hal/: analogin_api.h analogout_api.h buffer.h can_api.h can_helper.h dma_api.h emac_api.h ethernet_api.h gpio_api.h gpio_irq_api.h i2c_api.h lp_ticker_api.h mbed_gpio.c mbed_lp_ticker_api.c mbed_pinmap_common.c mbed_ticker_api.c mbed_us_ticker_api.c pinmap.h port_api.h pwmout_api.h rtc_api.h serial_api.h sleep_api.h spi_api.h ticker_api.h trng_api.h us_ticker_api.h
    ./mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/include/lwip/: api.h arch.h autoip.h debug.h def.h dhcp.h dhcp6.h dns.h err.h etharp.h ethip6.h icmp.h icmp6.h igmp.h inet.h inet_chksum.h init.h ip.h ip4.h ip4_addr.h ip4_frag.h ip6.h ip6_addr.h ip6_frag.h ip_addr.h mem.h memp.h mld6.h nd6.h netbuf.h netdb.h netif.h netifapi.h opt.h pbuf.h raw.h sio.h snmp.h sockets.h stats.h sys.h tcp.h tcpip.h timeouts.h udp.h
    ./mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/include/lwip/priv/: api_msg.h memp_priv.h memp_std.h tcp_priv.h tcpip_priv.h
    ./mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/include/netif/ppp/polarssl/: arc4.h des.h md4.h md5.h sha1.h
    ./mbed-os/cmsis/: arm_common_tables.h arm_const_structs.h arm_math.h core_ca9.h core_ca_mmu.h core_caFunc.h core_caInstr.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm4_simd.h core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSecureAccess.h core_cmSimd.h core_sc000.h core_sc300.h
    ./mbed-os/features/nanostack/FEATURE_NANOSTACK/sal-stack-nanostack/nanostack/platform/: arm_hal_aes.h arm_hal_phy.h os_whiteboard.h topo_trace.h
    ./mbed-os/features/FEATURE_COMMON_PAL/nanostack-hal-mbed-cmsis-rtos/: arm_hal_interrupt.c arm_hal_interrupt_private.h arm_hal_random.c arm_hal_timer.cpp ns_event_loop.c ns_event_loop.h ns_hal_init.c ns_hal_init.h
    ./mbed-os/features/FEATURE_COMMON_PAL/nanostack-libservice/mbed-client-libservice/platform/: arm_hal_interrupt.h arm_hal_nvm.h
    ./mbed-os/features/FEATURE_COMMON_PAL/mbed-client-randlib/mbed-client-randlib/platform/: arm_hal_random.h
    ./mbed-os/features/FEATURE_COMMON_PAL/sal-stack-nanostack-eventloop/nanostack-event-loop/platform/: arm_hal_timer.h eventloop_config.h
    ./mbed-os/platform/: Callback.h CallChain.cpp CallChain.h CircularBuffer.h critical.h CThunk.h FunctionPointer.h mbed_alloc_wrappers.cpp mbed_assert.c mbed_assert.h mbed_board.c mbed_critical.c mbed_debug.h mbed_error.c mbed_error.h mbed_interface.c mbed_interface.h mbed_mem_trace.c mbed_mem_trace.h mbed_preprocessor.h mbed_rtc_time.cpp mbed_semihost_api.c mbed_stats.c mbed_stats.h mbed_wait_api_no_rtos.c mbed_wait_api_rtos.cpp platform.h PlatformMutex.h retarget.cpp rtc_time.h semihost_api.h SingletonPtr.h toolchain.h Transaction.h wait_api.h
    ./mbed-os/features/nanostack/FEATURE_NANOSTACK/mbed-mesh-api/source/include/: callback_handler.h enet_tasklet.h mesh_system.h nd_tasklet.h static_config.h thread_tasklet.h
    ./mbed-os/features/nanostack/FEATURE_NANOSTACK/mbed-mesh-api/source/: CallbackHandler.cpp ethernet_tasklet.c LoWPANNDInterface.cpp mesh_system.c MeshInterfaceNanostack.cpp NanostackEthernetInterface.cpp nd_tasklet.c thread_tasklet.c ThreadInterface.cpp
    ./mbed-os/features/FEATURE_LWIP/lwip-interface/lwip-sys/arch/: cc.h lwip_checksum.c lwip_memcpy.c lwip_sys_arch.c perf.h sys_arch.h
    ./mbed-os/features/nanostack/FEATURE_NANOSTACK/sal-stack-nanostack/nanostack/: cca_api.h ccmLIB.h dev_stat_api.h dhcp_service_api.h ethernet_mac_api.h mac_api.h mac_common_defines.h mac_filter_api.h mac_mcps.h mlme.h multicast_api.h net_6lowpan_parameter_api.h net_address_extension.h net_fhss.h net_interface.h net_ipv6_api.h net_mle_api.h net_nvm_api.h net_nwk_scan.h net_pana_parameters_api.h net_polling_api.h net_rpl.h net_sleep.h net_thread_test.h ns_address.h ns_sha256.h ns_virtual_rf_api.h nwk_stats_api.h serial_mac_api.h shalib.h socket_api.h sw_mac.h thread_border_router_api.h thread_commissioning_api.h thread_dhcpv6_server.h thread_diagcop_lib.h thread_management_api.h thread_management_if.h thread_meshcop_lib.h thread_net_config_api.h whiteboard_api.h
    ./mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/include/netif/ppp/: ccp.h chap-md5.h chap-new.h chap_ms.h eap.h ecp.h eui64.h fsm.h ipcp.h ipv6cp.h lcp.h magic.h mppe.h ppp.h ppp_impl.h ppp_opts.h pppapi.h pppcrypt.h pppdebug.h pppoe.h pppol2tp.h pppos.h upap.h vj.h
    ./mbed-os/features/netsocket/: CellularInterface.h emac_stack_mem.h EthInterface.h MeshInterface.h NetworkInterface.cpp NetworkInterface.h NetworkStack.cpp NetworkStack.h nsapi.h nsapi_dns.cpp nsapi_dns.h nsapi_types.h Socket.cpp Socket.h SocketAddress.cpp SocketAddress.h TCPServer.cpp TCPServer.h TCPSocket.cpp TCPSocket.h UDPSocket.cpp UDPSocket.h WiFiAccessPoint.cpp WiFiAccessPoint.h WiFiInterface.h
    ./mbed-os/features/storage/FEATURE_STORAGE/cfstore/source/: cfstore_config.h cfstore_debug.h cfstore_fnmatch.c cfstore_fnmatch.h cfstore_list.h cfstore_svm.cpp cfstore_svm.h cfstore_test.c cfstore_test.h cfstore_utest.h cfstore_uvisor.h configuration_store.c
    ./mbed-os/targets/TARGET_Freescale/TARGET_MCUXpresso_MCUS/TARGET_MCU_K64F/device/: cmsis.h cmsis_nvic.c cmsis_nvic.h fsl_device_registers.h MK64F12.h MK64F12_features.h system_MK64F12.c system_MK64F12.h
    ./mbed-os/rtos/rtx/TARGET_CORTEX_M/: cmsis_os.h HAL_CM.c rt_CMSIS.c rt_Event.c rt_Event.h rt_HAL_CM.h rt_List.c rt_List.h rt_Mailbox.c rt_Mailbox.h rt_MemBox.c rt_MemBox.h rt_Memory.c rt_Memory.h rt_Mutex.c rt_Mutex.h rt_OsEventObserver.c rt_OsEventObserver.h rt_Robin.c rt_Robin.h rt_Semaphore.c rt_Semaphore.h rt_System.c rt_System.h rt_Task.c rt_Task.h rt_Time.c rt_Time.h rt_Timer.c rt_Timer.h rt_TypeDef.h RTX_CM_lib.h RTX_Conf_CM.c RTX_Config.h
    ./mbed-os/features/nanostack/FEATURE_NANOSTACK/coap-service/source/: coap_connection_handler.c coap_message_handler.c coap_security_handler.c coap_service_api.c
    ./mbed-os/features/nanostack/FEATURE_NANOSTACK/coap-service/source/include/: coap_connection_handler.h coap_message_handler.h coap_security_handler.h coap_service_api_internal.h
    ./mbed-os/features/nanostack/FEATURE_NANOSTACK/coap-service/coap-service/: coap_service_api.h
    ./mbed-os/features/FEATURE_COMMON_PAL/nanostack-libservice/source/libBits/: common_functions.c
    ./mbed-os/features/FEATURE_COMMON_PAL/nanostack-libservice/mbed-client-libservice/: common_functions.h ip6string.h ip_fsc.h ns_list.h ns_nvm_helper.h ns_trace.h ns_types.h nsdynmemLIB.h
    ./mbed-os/features/storage/FEATURE_STORAGE/cfstore/configuration-store/: configuration_store.h
    ./mbed-os/targets/TARGET_Freescale/TARGET_MCUXpresso_MCUS/TARGET_MCU_K64F/TARGET_FRDM/: crc.c crc.h device.h fsl_clock_config.c fsl_clock_config.h fsl_phy.c fsl_phy.h mbed_overrides.c PeripheralNames.h PeripheralPins.c PinNames.h
    ./mbed-os/features/FEATURE_COMMON_PAL/nanostack-hal-mbed-cmsis-rtos/cs_nvm/: cs_nvm.c
    ./mbed-os/targets/TARGET_Freescale/TARGET_MCUXpresso_MCUS/TARGET_MCU_K64F/: dma_reqs.h peripheral_clock_defines.h pwmout_api.c serial_api.c spi_api.c storage_driver.c trng_api.c us_ticker.c
    ./mbed-os/hal/storage_abstraction/: Driver_Common.h Driver_Storage.h
    ./mbed-os/features/FEATURE_LWIP/lwip-interface/: emac_lwip.c emac_stack_lwip.cpp eth_arch.h EthernetInterface.cpp EthernetInterface.h lwip_stack.c lwip_stack.h lwipopts.h
    ./mbed-os/events/equeue/: equeue.c equeue.h equeue_mbed.cpp equeue_platform.h equeue_posix.c
    ./mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/include/netif/: etharp.h lowpan6.h lowpan6_opts.h lwip_ethernet.h slipif.h
    ./mbed-os/features/FEATURE_COMMON_PAL/sal-stack-nanostack-eventloop/source/: event.c minar_hal_timer.cpp ns_timeout.c ns_timer.c ns_timer.h system_timer.c timer_sys.h
    ./mbed-os/events/: Event.h EventQueue.cpp EventQueue.h mbed_events.h
    ./mbed-os/features/FEATURE_COMMON_PAL/sal-stack-nanostack-eventloop/nanostack-event-loop/: eventOS_callback_timer.h eventOS_event.h eventOS_event_timer.h eventOS_scheduler.h
    ./mbed-os/features/storage/FEATURE_STORAGE/flash-journal/: flash_journal.h
    ./mbed-os/features/storage/FEATURE_STORAGE/flash-journal/flash-journal-strategy-sequential/: flash_journal_crc.c flash_journal_crc.h flash_journal_private.h flash_journal_strategy_sequential.h strategy.c support_funcs.c support_funcs.h
    ./mbed-os/targets/TARGET_Freescale/TARGET_MCUXpresso_MCUS/TARGET_MCU_K64F/drivers/: fsl_adc16.c fsl_adc16.h fsl_clock.c fsl_clock.h fsl_cmp.c fsl_cmp.h fsl_cmt.c fsl_cmt.h fsl_common.c fsl_common.h fsl_crc.c fsl_crc.h fsl_dac.c fsl_dac.h fsl_dmamux.c fsl_dmamux.h fsl_dspi.c fsl_dspi.h fsl_dspi_edma.c fsl_dspi_edma.h fsl_edma.c fsl_edma.h fsl_enet.c fsl_enet.h fsl_ewm.c fsl_ewm.h fsl_flash.c fsl_flash.h fsl_flexbus.c fsl_flexbus.h fsl_flexcan.c fsl_flexcan.h fsl_ftm.c fsl_ftm.h fsl_gpio.c fsl_gpio.h fsl_i2c.c fsl_i2c.h fsl_i2c_edma.c fsl_i2c_edma.h fsl_llwu.c fsl_llwu.h fsl_lptmr.c fsl_lptmr.h fsl_mpu.c fsl_mpu.h fsl_pdb.c fsl_pdb.h fsl_pit.c fsl_pit.h fsl_pmc.c fsl_pmc.h fsl_port.h fsl_rcm.c fsl_rcm.h fsl_rnga.c fsl_rnga.h fsl_rtc.c fsl_rtc.h fsl_sai.c fsl_sai.h fsl_sai_edma.c fsl_sai_edma.h fsl_sdhc.c fsl_sdhc.h fsl_sim.c fsl_sim.h fsl_smc.c fsl_smc.h fsl_uart.c fsl_uart.h fsl_uart_edma.c fsl_uart_edma.h fsl_vref.c fsl_vref.h fsl_wdog.c fsl_wdog.h
    ./mbed-os/features/frameworks/greentea-client/source/: greentea_metrics.cpp greentea_serial.cpp greentea_test_env.cpp
    ./mbed-os/features/frameworks/greentea-client/greentea-client/: greentea_metrics.h greentea_serial.h test_env.h
    ./mbed-os/rtos/rtx/TARGET_CORTEX_M/TARGET_RTOS_M4_M7/TOOLCHAIN_ARM/: HAL_CM4.c SVC_Table.S
    ./mbed-os/features/FEATURE_LWIP/lwip-interface/lwip-eth/arch/TARGET_Freescale/: hardware_init_MK64F12.c hardware_init_MK66F18.c k64f_emac.c k64f_emac_config.h lwipopts_conf.h
    ./mbed-os/features/FEATURE_COMMON_PAL/nanostack-libservice/source/libip6string/: ip6tos.c stoip6.c
    ./mbed-os/features/FEATURE_COMMON_PAL/nanostack-libservice/source/IPv6_fcf_lib/: ip_fsc.c
    ./mbed-os/features/nanostack/FEATURE_LOWPAN_ROUTER/TOOLCHAIN_ARM/TARGET_RTOS_M4_M7/: libnanostack_armcc_Cortex-M3_lowpan_router.ar
    ./mbed-os/features/nanostack/FEATURE_NANOSTACK/mbed-mesh-api/mbed-mesh-api/: LoWPANNDInterface.h mesh_interface_types.h MeshInterfaceNanostack.h NanostackEthernetInterface.h ThreadInterface.h
    ./mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/api/: lwip_api_lib.c lwip_api_msg.c lwip_err.c lwip_netbuf.c lwip_netdb.c lwip_netifapi.c lwip_sockets.c lwip_tcpip.c
    ./mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/core/ipv4/: lwip_autoip.c lwip_dhcp.c lwip_etharp.c lwip_icmp.c lwip_igmp.c lwip_ip4.c lwip_ip4_addr.c lwip_ip4_frag.c
    ./mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/core/: lwip_def.c lwip_dns.c lwip_inet_chksum.c lwip_init.c lwip_ip.c lwip_mem.c lwip_memp.c lwip_netif.c lwip_pbuf.c lwip_raw.c lwip_stats.c lwip_sys.c lwip_tcp.c lwip_tcp_in.c lwip_tcp_out.c lwip_timeouts.c lwip_udp.c
    ./mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/core/ipv6/: lwip_dhcp6.c lwip_ethip6.c lwip_icmp6.c lwip_inet6.c lwip_ip6.c lwip_ip6_addr.c lwip_ip6_frag.c lwip_mld6.c lwip_nd6.c
    ./mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/netif/: lwip_ethernet.c lwip_ethernetif.c lwip_lowpan6.c
    ./mbed-os/rtos/: Mail.h MemoryPool.h Mutex.cpp Mutex.h Queue.h rtos.h rtos_idle.c rtos_idle.h RtosTimer.cpp RtosTimer.h Semaphore.cpp Semaphore.h Thread.cpp Thread.h
    ./mbed-os/features/frameworks/utest/: mbed-utest-shim.cpp
    ./mbed-os/: mbed.h
    ./mbed-os/targets/TARGET_Freescale/: mbed_rtx.h
    ./mbed-os/features/FEATURE_COMMON_PAL/mbed-trace/source/: mbed_trace.c
    ./mbed-os/features/FEATURE_COMMON_PAL/mbed-trace/mbed-trace/: mbed_trace.h
    ./mbed-os/features/mbedtls/platform/src/: mbed_trng.c
    ./mbed-os/features/nanostack/FEATURE_NANOSTACK/nanostack-interface/: NanostackEthernetPhy.h NanostackInterface.cpp NanostackInterface.h NanostackPhy.h NanostackRfPhy.h
    ./mbed-os/features/FEATURE_COMMON_PAL/nanostack-libservice/source/libList/: ns_list.c
    ./mbed-os/features/FEATURE_COMMON_PAL/nanostack-libservice/source/nvmHelper/: ns_nvm_helper.c
    ./mbed-os/features/FEATURE_COMMON_PAL/nanostack-libservice/source/libTrace/: ns_trace.c
    ./mbed-os/features/FEATURE_COMMON_PAL/nanostack-libservice/source/nsdynmemLIB/: nsdynmemLIB.c
    ./mbed-os/features/FEATURE_COMMON_PAL/nanostack-hal-mbed-cmsis-rtos/nvm/: nvm_ram.c
    ./mbed-os/features/mbedtls/platform/inc/: platform_mbed.h
    ./mbed-os/features/FEATURE_COMMON_PAL/mbed-client-randlib/source/: randLIB.c
    ./mbed-os/features/FEATURE_COMMON_PAL/mbed-client-randlib/mbed-client-randlib/: randLIB.h
    ./mbed-os/features/FEATURE_COMMON_PAL/mbed-client-c/source/libCoap/src/: sn_coap_builder.c sn_coap_header_check.c sn_coap_parser.c sn_coap_protocol.c
    ./mbed-os/features/FEATURE_COMMON_PAL/mbed-client-c/nsdl-c/: sn_coap_header.h sn_coap_protocol.h sn_config.h sn_nsdl.h sn_nsdl_lib.h sn_nsdl_lib2.h
    ./mbed-os/features/FEATURE_COMMON_PAL/mbed-client-c/source/libCoap/src/include/: sn_coap_header_internal.h sn_coap_protocol_internal.h
    ./mbed-os/features/FEATURE_COMMON_PAL/mbed-client-c/source/libNsdl/src/: sn_grs.c sn_grs2.c sn_nsdl.c sn_nsdl2.c
    ./mbed-os/features/FEATURE_COMMON_PAL/mbed-client-c/source/libNsdl/src/include/: sn_grs.h sn_grs2.h
    ./mbed-os/targets/TARGET_Freescale/TARGET_MCUXpresso_MCUS/TARGET_MCU_K64F/device/TOOLCHAIN_ARM_STD/: startup_MK64F12.S sys.cpp
    ./mbed-os/features/storage/FEATURE_STORAGE/storage-volume-manager/source/: storage_volume.cpp storage_volume_manager.cpp
    ./mbed-os/features/storage/FEATURE_STORAGE/storage-volume-manager/storage-volume-manager/: storage_volume_manager.h
    ./mbed-os/features/frameworks/unity/source/: unity.c
    ./mbed-os/features/frameworks/unity/unity/: unity.h unity_config.h unity_internals.h
    ./mbed-os/features/frameworks/utest/source/: unity_handler.cpp utest_case.cpp utest_default_handlers.cpp utest_greentea_handlers.cpp utest_harness.cpp utest_shim.cpp utest_stack_trace.cpp utest_types.cpp
    ./mbed-os/features/frameworks/utest/utest/: unity_handler.h utest.h utest_case.h utest_default_handlers.h utest_harness.h utest_scheduler.h utest_serial.h utest_shim.h utest_specification.h utest_stack_trace.h utest_types.h
  group MQTT
    ./MQTT/FP/: FP.h
    ./MQTT/: MQTTAsync.h MQTTClient.h MQTTEthernet.h MQTTLogging.h MQTTmbed.h MQTTSocket.h
    ./MQTT/MQTTPacket/: MQTTConnect.h MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTPacket.c MQTTPacket.h MQTTPublish.h MQTTSerializePublish.c MQTTSubscribe.h MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribe.h MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c StackTrace.h
  group NTPClient
    ./NTPClient/: NTPClient.cpp NTPClient.h
  group SDFileSystem
    ./SDFileSystem/FATFileSystem/ChaN/: ccsbcs.cpp diskio.cpp diskio.h ff.cpp ff.h ffconf.h integer.h
    ./SDFileSystem/FATFileSystem/: FATDirHandle.cpp FATDirHandle.h FATFileHandle.cpp FATFileHandle.h FATFileSystem.cpp FATFileSystem.h MemFileSystem.h
    ./SDFileSystem/: SDFileSystem.cpp SDFileSystem.h
  group SPI_STMPE610
    ./SPI_STMPE610/: SPI_STMPE610.cpp SPI_STMPE610.h
  group SPI_TFT_ILI9341
    ./SPI_TFT_ILI9341/: GraphicsDisplay.cpp GraphicsDisplay.h SPI_TFT_ILI9341.cpp SPI_TFT_ILI9341.h TextDisplay.cpp TextDisplay.h
  group TFT_fonts
    ./TFT_fonts/: Arial12x12.h Arial24x23.h Arial28x28.h font_big.h
  group XBeeLib
    ./XBeeLib/Frames/: 802_Frames.cpp 802_Frames.h ApiFrame.cpp ApiFrame.h AtCmdFrame.cpp AtCmdFrame.h DigiMeshFrames.cpp DigiMeshFrames.h ZigbeeFrames.cpp ZigbeeFrames.h
    ./XBeeLib/XBee/: Addresses.h AtCommands.cpp RadioConfig.cpp XBee.cpp XBee.h
    ./XBeeLib/Utils/: Debug.h Utils.cpp Utils.h
    ./XBeeLib/DigiLogger/: DigiLogger.cpp DigiLogger.h DigiLoggerMbedSerial.cpp DigiLoggerMbedSerial.h
    ./XBeeLib/FrameHandlers/: FH_AtCmdResp.cpp FH_AtCmdResp.h FH_IoDataSample802.cpp FH_IoDataSample802.h FH_IoDataSampleDM.cpp FH_IoDataSampleDM.h FH_IoDataSampleZB.cpp FH_IoDataSampleZB.h FH_ModemStatus.cpp FH_ModemStatus.h FH_RxPacket802.cpp FH_RxPacket802.h FH_RxPacketDM.cpp FH_RxPacketDM.h FH_RxPacketZB.cpp FH_RxPacketZB.h FrameHandler.cpp FrameHandler.h
    ./XBeeLib/FrameBuffer/: FrameBuffer.cpp FrameBuffer.h
    ./XBeeLib/IO/: IO.h IOSample802.cpp IOSample802.h IOSampleDM.cpp IOSampleDM.h IOSampleZB.cpp IOSampleZB.h
    ./XBeeLib/RemoteXBee/: RemoteXBee.cpp RemoteXBee.h
    ./XBeeLib/XBee802/: XBee802.cpp XBee802.h
    ./XBeeLib/XBeeDM/: XBeeDM.cpp XBeeDM.h
    ./XBeeLib/: XBeeLib.h
    ./XBeeLib/XBeeZB/: XBeeZB.cpp XBeeZB.h
